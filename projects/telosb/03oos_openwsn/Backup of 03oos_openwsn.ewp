# IAR project Backup of 03oos_openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\telosb\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\boards\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\chips\sht11\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\kernel\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cexample\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cleds\; ..\..\..\openapps\csensors\; ..\..\..\openapps\cstorm\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\opencoap\; ..\..\..\openapps\rrt\; ..\..\..\openapps\techo\; ..\..\..\openapps\tohlone\; ..\..\..\openapps\uecho\; ..\..\..\openapps\uinject\; ..\..\..\openapps\userialbridge\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group bsp/boards
    ../../../bsp/boards/: board.h crypto_engine.h debugpins.h eui64.h i2c.h leds.h radio.h sctimer.h sensors.h spi.h toolchain_defs.h uart.h
  group bsp/boards/common
    ../../../bsp/boards/common/: abstimer.c abstimers2.c aes_cbc.c aes_cbc.h aes_ccms.c aes_ccms.h aes_ctr.c aes_ctr.h aes_ecb.c aes_ecb.h dummy_crypto_engine.c dummy_crypto_engine.h firmware_crypto_engine.c firmware_crypto_engine.h
  group bsp/boards/telosb
    ../../../bsp/boards/telosb/: adc_sensor.c adc_sensor.h board.c board_crypto_engine.c board_crypto_engine.h board_info.h debugpins.c eui64.c leds.c sctimer.c sensors.c spi.c uart.c
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.c cc2420.h cc2420_crypto.c cc2420_crypto.h radio.c
  group bsp/chips/sht11
    ../../../bsp/chips/sht11/: sht11.c sht11.h
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h opensensors.c opensensors.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/: scheduler.h
  group kernel/openos
    ../../../kernel/openos/: scheduler.c
  group openapps
    ../../../openapps/: openapps.c openapps.h
  group openapps/c6t
    ../../../openapps/c6t/: c6t.c c6t.h
  group openapps/cexample
    ../../../openapps/cexample/: cexample.c cexample.h
  group openapps/cinfo
    ../../../openapps/cinfo/: cinfo.c cinfo.h
  group openapps/cleds
    ../../../openapps/cleds/: cleds.c cleds.h
  group openapps/csensors
    ../../../openapps/csensors/: csensors.c csensors.h
  group openapps/cstorm
    ../../../openapps/cstorm/: cstorm.c cstorm.h
  group openapps/cwellknown
    ../../../openapps/cwellknown/: cwellknown.c cwellknown.h
  group openapps/opencoap
    ../../../openapps/opencoap/: opencoap.c opencoap.h
  group openapps/rrt
    ../../../openapps/rrt/: rrt.c rrt.h
  group openapps/techo
    ../../../openapps/techo/: techo.c techo.h
  group openapps/tohlone
    ../../../openapps/tohlone/: tohlone.c tohlone.h tohlone_webpages.c tohlone_webpages.h
  group openapps/uecho
    ../../../openapps/uecho/: uecho.c uecho.h
  group openapps/uinject
    ../../../openapps/uinject/: uinject.c uinject.h
  group openapps/userialbridge
    ../../../openapps/userialbridge/: userialbridge.c userialbridge.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154_dummy_security.c IEEE802154_dummy_security.h IEEE802154_security.c IEEE802154_security.h ieee802154_security_driver.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h schedule.c schedule.h sf0.c sf0.h sixtop.c sixtop.h
  group openstack/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openstack/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openstack/04-TRAN
    ../../../openstack/04-TRAN/: opentcp.c opentcp.h openudp.c openudp.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
  group projects/common/03oos_openwsn
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h

# IAR project 02drv_openserial.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\telosb\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\boards\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\chips\sht11\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h crypto_engine.h debugpins.h eui64.h i2c.h leds.h radio.h radiotimer.h sctimer.h sensors.h spi.h toolchain_defs.h uart.h
  group bsp/boards/common
    ../../../bsp/boards/common/: abstimer.c abstimers2.c aes_cbc.c aes_cbc.h aes_ccms.c aes_ccms.h aes_ctr.c aes_ctr.h aes_ecb.c aes_ecb.h dummy_crypto_engine.c dummy_crypto_engine.h firmware_crypto_engine.c firmware_crypto_engine.h
  group bsp/boards/telosb
    ../../../bsp/boards/telosb/: adc_sensor.c adc_sensor.h board.c board_crypto_engine.c board_crypto_engine.h board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c sensors.c spi.c uart.c
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.c cc2420.h cc2420_crypto.c cc2420_crypto.h radio.c
  group bsp/chips/sht11
    ../../../bsp/chips/sht11/: sht11.c sht11.h
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h opensensors.c opensensors.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group projects/common/02drv_openserial
    ../../common/02drv_openserial/: 02drv_openserial.c
